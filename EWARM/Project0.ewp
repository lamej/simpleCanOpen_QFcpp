# IAR project Project0.ewp, settings and files
configuration Project0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F091RB ST STM32F091RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F091xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc; ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F0xx/Include; ../Drivers/CMSIS/Include; ../../../qpcpp702/qpcpp/include; ../../../qpcpp702/qpcpp/src; ../../../qpcpp702/qpcpp/ports/arm-cm/qk/iar
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project0.hex
  ILINK.IlinkOutputFile: Project0.out
  ILINK.IlinkIcfFile: stm32f091xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../: readme.txt
  group Application/EWARM
    ./: startup_stm32f091xc.s
  group Application/QCPP
    ../../../qpcpp702/qpcpp/src/qf/: qep_hsm.cpp qep_msm.cpp qf_act.cpp qf_actq.cpp qf_defer.cpp qf_dyn.cpp qf_mem.cpp qf_ps.cpp qf_qact.cpp qf_qeq.cpp qf_qmact.cpp qf_time.cpp
    ../../../qpcpp702/qpcpp/src/qk/: qk.cpp
  group Application/QCPP/Ports
    ../../../qpcpp702/qpcpp/ports/arm-cm/qk/iar/: qk_port.cpp
  group Application/User/Core
    ../Core/Src/: applicFactory.cpp AX71V20_OD.cpp AX71V20Core.cpp bsp.cpp bsp_it.cpp cabinCallHandler.cpp CANOpen.cpp digitalInputHandler.cpp display.cpp ledCallHandler.cpp remoteMsgServer.cpp RPDO2_DataUnpacker.cpp rpdos.cpp systemIntegrity.cpp tpdos.cpp main.c gpio.c can.c tim.c wwdg.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_can.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_wwdg.c
